<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm8l050j3m3_rgbw_adc_dev.ewp</path>
    </project>
    <batchBuild />
</workspace>
